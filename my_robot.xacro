Commit message: Add files via upload

File: my_robot.xacro (robot description, xacro)
@@ -55,5 +55,5 @@
     </visual>
   </link>
-  <link name='cemera'>
+  <link name='camera'>
 	<visual>
 		<origin xyz="0 0 0" rpy="0 0 0"/>
